# Keil uVision project motorLib.uvprojx, settings and files
target motorLib (6090000::V6.9::.\ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: motorLib +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;     ../Drivers/STM32F4xx_HAL_Driver/Inc;     ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;     ../Drivers/CMSIS/Include;     ..\motor;     ..\Drivers;     ..\PID;     ..\task;     ..\MPU6050_F4;     ..\MPU6050_F4\eMPL;     ..\MDK-ARM;     ..\HAL_EasyGyro9250-master
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group motor
    ../motor/: motor.c motor.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group pid
    ../PID/: PID.c PID.h
  group task
    ../task/: easyTask.c easyTask.h
  group control
    ./: control.c control.h
  group MPU6050
    ../MPU6050_F4/: mpu6050.c mpuiic.c
    ../MPU6050_F4/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group UART_COM
    ./: uart_com.c uart_com.h
  group MPU9250
    ../HAL_EasyGyro9250-master/: filter.c filter.h mpu9250.c mpu9250.h mytype.h Quad_Math.c quad_math.h
software components: CMSIS:CORE 5.6.0
